# Keil uVision project KeilRTOS.uvproj, settings and files
target KeilRTOS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: KeilRTOS
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Keil\Lib\inc;.\Keil\User;.\Keil\Start;.\RTOS\Inc;D:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Keil/Start/: startup_stm32f10x_hd.s
  group Lib
    ./Keil/Lib/inc/: core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
    ./Keil/Lib/src/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group User
    ./Keil/User/: main.c
  group RTOS
    ./RTOS/Src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
